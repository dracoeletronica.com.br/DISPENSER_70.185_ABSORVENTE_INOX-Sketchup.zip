Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: P:\ENGENHARIA\DESENVOLVIMENTO\DISPENSER_ABSORVENTE_INOX\BIM\DISPENSER_70.185_ABSORVENTE_INOX.IFC
Time: 2025-03-17T14:33:25+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Area Measure: 0.9611169224016338; Mass Measure: 3.0500121728829788; Volume Measure: 0.0003873661165772

# IfcBuilding, default Building
PSet_Mass_Property - Area Measure: 0.9611169224016338; Mass Measure: 3.0500121728829788; Volume Measure: 0.0003873661165772

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Area Measure: 0.9611169224016338; Mass Measure: 3.0500121728829788; Volume Measure: 0.0003873661165772

# IfcElementAssembly, DISPENSER_ABSORVENTE_INOX_VER.06
In: default BuildingStorey
PSet_Mass_Property - Area Measure: 0.9611169224016338; Mass Measure: 3.0500121728829788; Volume Measure: 0.0003873661165772
